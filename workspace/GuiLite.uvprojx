# Keil uVision project GuiLite.uvprojx, settings and files
target GuiLite (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GuiLite (library)
  AfterMake: sync_build.bat GuiLite-keil
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ./
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: bitmap.cpp display.cpp theme.cpp wnd.cpp word.cpp
    ./core/adapter/: api_unknow.cpp
  group widgets
    ./widgets/: button.cpp label.cpp wave_buffer.cpp wave_ctrl.cpp
